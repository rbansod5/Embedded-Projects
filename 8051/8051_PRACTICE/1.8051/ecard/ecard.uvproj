# Keil uVision project ecard.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ecard +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c e_card.c e_card_function.c eeprom.c i2c.c keypad.c lcd.c uart.c delay.h e_card_function.h i2c.h i2c_defines.h keypad.h lcd.h lcd1.h types.h uart.h
