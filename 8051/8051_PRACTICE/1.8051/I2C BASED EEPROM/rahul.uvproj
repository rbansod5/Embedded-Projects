# Keil uVision project rahul.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: rahul +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c eeprom.c i2c.c lcd.c delay.h i2c.h i2c_defines.h lcd.h types.h e_card.c e_card_function.c e_card_function.h
