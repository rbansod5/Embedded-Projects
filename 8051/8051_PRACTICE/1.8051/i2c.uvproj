# Keil uVision project i2c.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: i2c
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: i2c.c delay.c eeprom.c types.h lcd.h i2c_defines.h i2c.h lcd.c
